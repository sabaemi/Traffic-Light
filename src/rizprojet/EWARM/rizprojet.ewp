# IAR project rizprojet.ewp, settings and files
configuration rizprojet (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401VC ST STM32F401VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: rizprojet.out
  ILINK.IlinkIcfFile: stm32f401xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: 
  group Application/EWARM
    C:/Users/ITPardaz/Documents/rizprojet//EWARM/: startup_stm32f401xc.s
  group Application/User
    ./: 
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c
  group Drivers
    ./: 
  group Drivers/STM32F4xx_HAL_Driver
    ./: 
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f4xx.c
